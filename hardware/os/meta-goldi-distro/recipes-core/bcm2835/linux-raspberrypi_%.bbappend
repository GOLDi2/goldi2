FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://disable-strict_devmem.cfg"