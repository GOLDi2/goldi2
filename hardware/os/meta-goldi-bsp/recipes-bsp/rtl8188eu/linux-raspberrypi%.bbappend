FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://disable_kernel_8188_driver.cfg"